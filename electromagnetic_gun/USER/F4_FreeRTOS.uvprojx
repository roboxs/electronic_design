# Keil uVision project F4_FreeRTOS.uvprojx, settings and files
target F4_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F4_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,MPU6500,EMPL_TARGET_STM32F4,MPL_LOG_NDEBUG=1,EMPL,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\FWLIB\inc;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\include;..\BSP\inc;..\TASK\inc;..\DRIVER\inc;..\MATH;..\DMP\driver\eMPL;..\DMP\driver\include;..\DMP\driver\stm32L;..\DMP\eMPL-hal;..\DMP\mllite;..\DMP\mpl;..\DSP\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f427xx.s
  group BSP
    ../BSP/src/: bsp_system.c bsp_gpio.c bsp_uart.c bsp_dma.c bsp_tim.c bsp_can.c bsp_nvic.c
  group TASK
    ../TASK/src/: task_led.c task_imu.c task_vision.c task_control.c
  group DRIVER
    ../DRIVER/src/: driver_control.c driver_filter.c driver_iic.c driver_imu.c driver_encoder.c driver_crc.c
  group MATH
    ../MATH/: user_math.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_can.c stm32f4xx_exti.c
  group FREERTOS
    ../FreeRTOS/: tasks.c list.c queue.c timers.c event_groups.c croutine.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group DMP
    ../DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../DMP/driver/stm32L/: log_stm32.c
    ../DMP/eMPL-hal/: eMPL_outputs.c
    ../DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../DMP/mpl/: libmpllib.lib
  group DSP
    ../DSP/: arm_cortexM4lf_math.lib
